# Keil uVision project Calculator.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: MKV11Z128VLC7 NXP
  pack: NXP.MKV11Z7_DFP.16.0.0
  cpu: IRAM(0x1ffff000,0x4000) IROM(0x00000000,0x020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Calculator
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: .\RTE\Device\MKV11Z128VLC7\MKV11Z128xxx7_flash.scf
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 6.2.0, Device:CMSIS:MKV11Z7_header 1.0.0, Device:CMSIS:MKV11Z7_system 1.0.0, Device:Startup 1.1.0
